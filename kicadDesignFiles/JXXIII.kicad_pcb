# Repository jordibinefa/s4aPLB

File README.md:

# s4aPLB
S4A Programming Learning Board (KiCAD files)

## KiCad design kicadDesignFiles/JXXIII.kicad_pcb

Parts:
C1C1, C1S1: 100nF
D1C1, D1S1: DIODESCH
D2C1, D2S1, D3C1, D3S1, D4C1, D4S1, D5C1, D5S1, D10AC1, D10AS1, D11AC1, D11AS1, D12AC1, D12AS1, D13AC1, D13AS1: LED
D2C2, D2S2: 1N4148
K4, K5, K6: CONN_3
KA4: CONN_3
P0, P1, P1A1, P2: CONN_3
P1E1, P2E1: CONN_5X2
P3, P3A1, P10, P11, P12, P13: CONN_2
P5: CONN_7
PB2, PB3: CONN_2
PBA4, PBA5: CONN_2
PCOMM1: CONN_4X2
PJ0: CONN_5
P_5V1, P_5V2: CONN_2
P_JUMPERS_TX_RX1: CONN_4X2
P_TECL_1: CONN_5
R10AC1, R10AS1, R10C1, R10S1, R11AC1, R11AS1, R11C1, R11S1, R12AC1, R12AS1, R12C1, R12S1, R13AC1, R13AS1, R13C1, R13S1, R22C1, R22S1, R32C1, R32S1, R42C1, R42S1, R52C1, R52S1: 1K
R21C1, R21S1, R31C1, R31S1, R41C1, R41S1, R51C1, R51S1: 10K
RA3C1, RA3S1: 10K
RPULLC_IO4: 10K
RPULLS_IO4: 10K
SW1, SW2, SW3, SW4: PUSH_BUTTON
U1: ARDUINO_NANO; DIL20

Connections:
/AD0: P1E1.9, P3.1, P3A1.1, RA3C1.1, RA3S1.1, U1.4
/AD1: P0.1, P1E1.8, PJ0.3, U1.5
/AD2: P1.2 (PM), P1A1.2 (PM), P1E1.7, PJ0.4, U1.6
/AD3: P1E1.6, P2.3, U1.7
/AD4: D4C1.2 (K), D4S1.2 (K), P2E1.8, P_TECL_1.3, R41C1.2, R41S1.2, SW4.4, U1.8
/AD5: D5C1.2 (K), D5S1.2 (K), P2E1.9, P_TECL_1.2, R51C1.2, R51S1.2, SW2.4, U1.9
/AD6: P5.5, U1.10
/AD7: P5.6, U1.11
/IO0: P_JUMPERS_TX_RX1.6, P_JUMPERS_TX_RX1.8, U1.16
/IO1: P_JUMPERS_TX_RX1.2, P_JUMPERS_TX_RX1.4, U1.17
/IO2: D2C1.2 (K), D2S1.2 (K), PJ0.5, P_TECL_1.4, R21C1.2, R21S1.2, RPULLC_IO4.1, RPULLS_IO4.1, SW1.4, U1.20
/IO3: D3C1.2 (K), D3S1.2 (K), P_TECL_1.5, R31C1.2, R31S1.2, SW3.4, U1.21
/IO4: P1E1.5, P5.2, U1.22
/IO5: P1E1.4, P5.3, U1.23
/IO6: P1E1.3, P5.4, U1.24
/IO7: K5.3, P1E1.2, U1.25
/IO8: K6.3, P2E1.7, U1.26
/IO9: K4.3, KA4.3, P2E1.6, U1.27
/MISO: P2E1.3, R12AC1.1, R12AS1.1, R12C1.1, R12S1.1, U1.30
/MOSI: P2E1.4, R11AC1.1, R11AS1.1, R11C1.1, R11S1.1, U1.29
/SCK: P2E1.2, R13AC1.1, R13AS1.1, R13C1.1, R13S1.1, U1.1
/SS: P2E1.5, R10AC1.1, R10AS1.1, R10C1.1, R10S1.1, U1.28
/V_5V: D1C1.1 (A), D1S1.1 (A), P0.2 (PM), P1.1, P1A1.1, P1E1.10, P2.2 (PM), P2E1.10, P3.2 (PM), P3A1.2 (PM), P5.7, PCOMM1.8, PJ0.2, P_5V1.1, P_5V2.1, R21C1.1, R21S1.1, R22C1.1, R22S1.1, R31C1.1, R31S1.1, R32C1.1, R32S1.1, R41C1.1, R41S1.1, R42C1.1, R42S1.1, R51C1.1, R51S1.1, R52C1.1, R52S1.1, RPULLC_IO4.2, RPULLS_IO4.2, U1.3, U1.12
/V_SERVO: C1C1.1, C1S1.1, D1C1.2 (K), D1S1.2 (K), D2C2.2 (K), D2S2.2 (K), K5.2 (PM), K6.2 (PM)
GND: C1C1.2, C1S1.2, D2C2.1 (A), D2S2.1 (A), D10AC1.2 (K), D10AS1.2 (K), D11AC1.2 (K), D11AS1.2 (K), D12AC1.2 (K), D12AS1.2 (K), D13AC1.2 (K), D13AS1.2 (K), K4.1, K5.1, K6.1, KA4.1, P0.3, P1.3, P1A1.3, P1E1.1, P2.1, P2E1.1, P5.1, P10.2 (PM), P11.2 (PM), P12.2 (PM), P13.2 (PM), PB2.2 (PM), PB3.2 (PM), PBA4.2 (PM), PBA5.2 (PM), PCOMM1.1, PJ0.1, P_5V1.2 (PM), P_5V2.2 (PM), P_TECL_1.1, RA3C1.2, RA3S1.2, SW1.2, SW2.2, SW3.2, SW4.2, U1.14, U1.19
unnamed: P11.1, R11C1.2, R11S1.2
unnamed: P12.1, R12C1.2, R12S1.2
unnamed: P10.1, R10C1.2, R10S1.2
unnamed: D4C1.1 (A), D4S1.1 (A), R42C1.2, R42S1.2
unnamed: P13.1, R13C1.2, R13S1.2
unnamed: PB2.1, SW1.1
unnamed: PB3.1, SW3.1
unnamed: PBA4.1, SW4.1
unnamed: PBA5.1, SW2.1
unnamed: D11AC1.1 (A), D11AS1.1 (A), R11AC1.2, R11AS1.2
unnamed: D13AC1.1 (A), D13AS1.1 (A), R13AC1.2, R13AS1.2
unnamed: D12AC1.1 (A), D12AS1.1 (A), R12AC1.2, R12AS1.2
unnamed: D10AC1.1 (A), D10AS1.1 (A), R10AC1.2, R10AS1.2
unnamed: PCOMM1.4, P_JUMPERS_TX_RX1.1, P_JUMPERS_TX_RX1.5
unnamed: PCOMM1.2, P_JUMPERS_TX_RX1.3, P_JUMPERS_TX_RX1.7
unnamed: D3C1.1 (A), D3S1.1 (A), R32C1.2, R32S1.2
unnamed: D5C1.1 (A), D5S1.1 (A), R52C1.2, R52S1.2
unnamed: D2C1.1 (A), D2S1.1 (A), R22C1.2, R22S1.2

Notes on the sheet:
SDA
SCL
BRUNZIDOR
AUX 4, 5, 6, AD6 I AD7
SERVO 1 7
SERVO 2 8
LED 10
LED 11
LED 13
POTENCIÒMETRE A1
LM35 A2
IR A3
LDR A0
LED 12
TECLAT
ALIM USB
PCOMM
CFG
BOTÓ 2
BOTÓ 3
BOTÓ A5
BOTÓ A4
ALTERNATIVA DE MUNTATGE (SMD O CONVENCIONAL) C : COMPONENT CONVENCIONAL S : COMPONENT SMD
GND
+5V
VRx
VRy
JOYSTICK

Board: 2 copper layers, 73.0 x 74.9 mm, 92 parts (1 on the bottom side), 43 nets.

Other parts of the board:
VAL: logo_eCat
VAL#2: logo_eCat
